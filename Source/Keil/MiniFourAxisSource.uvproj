# Keil uVision project MiniFourAxisSource.uvproj, settings and files
target MiniFourAxisSource (ARM-ADS)
  device: Mini54FDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: MiniFourAxisSource +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\Mini51Series\Include;..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group Library
    ../Library/StdDriver/src/: sys.c uart.c retarget.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c spi.c timer.c
  group User
    ./: main.c LED.c Timer_Ctrl.c Motor.c Battery.c UartCtrl.c FlashCtrl.c RC.c FailSafe.c PID.c Control.c ConfigTable.c NVT_I2C.c filter.c IMUSO3.c IMU.c MPU6050.c I2Cdev.c DMP.c
  group Include
    ./: def.h led.h Timer_Ctrl.h Motor.h Battery.h UartCtrl.h FlashCtrl.h RC.h FailSafe.h PID.h Control.h ConfigTable.h MPU6050.h NVT_I2C.h I2CDev.h filter.h IMU.h IMUSO3.h DMP.h
