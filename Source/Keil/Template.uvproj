# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: Mini54LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\Mini51Series\Include;..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group Library
    ../Library/StdDriver/src/: sys.c uart.c retarget.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c spi.c timer.c
  group User
    ./: main.c
  group Include
    ./: def.h
